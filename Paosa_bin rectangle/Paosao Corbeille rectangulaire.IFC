Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Paosao Corbeille rectangulaire.IFC
Time: 2020-07-01T12:00:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: PAO-COR-45L-STRUC-001_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 34.5258; Area Measure: 4.98505; Volume Measure: 0.00838235
